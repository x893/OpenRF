# Keil uVision project OpenRF_CM3_RFM69HW.uvprojx, settings and files
target OpenRF_EFM32_RFM69HW (ARM-ADS)
  device: EFM32GG990F1024 Energy Micro
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(48000000) ELITTLE
  output: OpenRF_CM3_RFM69HW
  c flags: Optim=1 OneElfS=1
  c define: MICRO_IS_EFM32 RADIO_SX1231
  c include: ..\..\SourceCode\MicrocontrollerAPI\EFM32
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ./App/: OpenRF_CM3_RFM69HW.c
    ../../SourceCode/Utility/: atProcessor.c
    ../../SourceCode/OpenRF_MAC/: openrf_mac.c
    ../../SourceCode/Radio/SX1231/: radioapi.c
    ../../SourceCode/MicrocontrollerAPI/EFM32/: microapi.c
  group ::Device
    RTE/Device/EFM32GG990F1024/: RTE_Device.h startup_efm32gg.s system_efm32gg.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
